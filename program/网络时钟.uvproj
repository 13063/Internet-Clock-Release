# Keil uVision project 网络时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 网络时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c tm1638.c tm1638.h public.h public.c ds1302.h ds1302.c iic.h iic.c ssd1306.c ssd1306.h DS18B20.c DS18B20.h OneWire.c OneWire.h uart.c uart.h
